# Keil uVision project 06b-UART_Rx_Tx_Lcd.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 06b-UART_Rx_Tx_Lcd +hex
  AfterMake: fromelf --bin 06b-UART_Rx_Tx_Lcd.axf --output 06b-UART_Rx_Tx_Lcd.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c gpio.c lcd.c system_LPC17xx.c systick.c uart.c gpio.h lcd.h stdutils.h systick.h uart.h delay.h delay.c
software components: CMSIS:CORE 5.1.2
